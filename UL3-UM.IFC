Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: UL3-UM.IFC
Time: 2021-09-09T06:03:52
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: LED Streifen BIM_515019020 LM "300" mit 18 Everlight LEDs
In: Default Storey
Material: Alu
SolidWorks Custom Properties - Version 1: SL - LED >5500K kalt weiß BLF 100%; Version 2: SN - LED >4000K neutralweiß BLF 100%

# IfcBuildingElementProxy: ULTIMO Folien BIM_UL3 UM Pikto
In: Default Storey
Material: PVC Klebefolie
SolidWorks Custom Properties - Version 1: 20 - Piktoset LMU/O/R/L DIN 7010; Version 2: 24 - Piktoset LM-OR/OL-UR/UL DIN7010

# IfcBuildingElementProxy: ULTIMO Montagefläche BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: ULTIMO Sockel BIM_815710110 UL Sockel weiß
In: Default Storey
Material: PC
SolidWorks Custom Properties - Gewicht: 188.52; Material: PC

# IfcBuildingElementProxy: ULTIMO Technik BIM_ULTIMO Technik
In: Default Storey
Material: Material Platine FR-4
SolidWorks Custom Properties - Version 1: 0 - zum Anschluss an NVB-Box; Version 2: AH3 - AT.DS od.BS,LFP 3,2V 3h 120Lm; Version 3: AX3 - AT.DS & BS,LFP 3,2V 3h 120lm; Version 4: AX8 - AT.DS & BS,LFP 3,2V 8h 120lm; Version 5: C - zentr. Vers. AC/DC Adressmodul; Version 6: E - für zentrale Versorgung AC/DC; Version 7: FM3 - AT.DS&BS, LFP3,2V 3h RC250; Version 8: FM8 - AT.DS&BS, LFP3,2V 8h RC250; Version 9: M3E - AT.DS&BS, LFP3,2V 3h; Version 10: M8E - AT.DS&BS, LFP3,2V 8h; Version 11: X - Einzel-Batt.DS&BS 7,2V Akku 3h

# IfcBuildingElementProxy: ULTIMO ultra hohe Haube BIM
In: Default Storey
Material: PC
SolidWorks Custom Properties - Material: PC; Gewicht: 421.53

# IfcBuildingElementProxy: URL BIM
In: Default Storey
Material: PC
SolidWorks Custom Properties - Material: PC; Gewicht: 86.69

# IfcElementAssembly: UL3-UM
In: Default Storey
PSet_Mass_Property - Mass Measure: 0.875645; Area Measure: 0.887039 m2; Volume Measure: 0.000749746 m3
